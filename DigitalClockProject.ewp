# IAR project DigitalClockProject.ewp, settings and files
configuration Debug (8051, debug)
  General.OGChipSelectMenu: AT89S52 AT89S52
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 1
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Microchip\lnk51ew_AT89S52.xcl
configuration Release (8051)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl8051Normal.h
  General.OGChipSelectMenu: 8052 Generic 8052
  ICC8051.CCDefines: NDEBUG
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\_generic\lnk51ew_8052.xcl
  group (top)
    ./: ds1307.cpp ds1307.h iic.cpp iic.h liquid_crystal.cpp liquid_crystal.h main.cpp pin_mapping.h print.cpp print.h timer.cpp timer.h
